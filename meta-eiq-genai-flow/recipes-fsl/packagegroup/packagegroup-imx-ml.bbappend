# Remove onnxruntime-tests from RDEPENDS
RDEPENDS:${PN}:remove = "onnxruntime-tests"